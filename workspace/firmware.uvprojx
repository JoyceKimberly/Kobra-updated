# Keil uVision project firmware.uvprojx, settings and files
target firmware_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.9
  cpu: IRAM(0x1FFF8000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: firmware +hex
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: BOARD_F_CPU=84000000,HC32F460,TARGET_HC32F46x,STM32F4xx,USE_DEVICE_DRIVER_LIB,__TARGET_FPU_VFP,__FPU_PRESENT=1,__CC_ARM,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__MPU_PRESENT=1,STM32_HIGH_DENSITY,ARDUINO_ARCH_STM32F1,ARDUINO_ARCH_STM32,REDIRECT_PRINTF_TO_SERIAL,ARDUINO=100,__STDC_CONSTANT_MACROS,__STDC_LIMIT_MACROS
  c misc: --gnu --diag_suppress=186,66 --cpp11 --multifile
  c include: ..\Marlin;..\Marlin\lib\component\adc;..\Marlin\lib\component\i2c;..\Marlin\lib\component\sdio;..\Marlin\lib\middleware\sd_card\inc;..\Marlin\lib\component\spi;..\Marlin\lib\component\uart;..\Marlin\lib\libraries\Utility;..\Marlin\lib\cores\arduino\drivers;..\Marlin\lib\cores\ddl\library;..\Marlin\lib\cores\ddl\library\inc;..\Marlin\lib\cores\arduino;..\Marlin\lib\usb;..\Marlin\lib\variants;..\Marlin\lib\main;..\Marlin\lib\cores\ddl;..\Marlin\lib\libraries\SoftwareSerial;..\Marlin\lib\libraries\TMCStepper;..\Marlin\lib\libraries\TMCStepper\source;..\Marlin\lib\cores\arduino\drivers;..\Marlin\lib\libraries\FatFs;..\Marlin\src;..\Marlin\src\core;..\Marlin\src\lcd;..\Marlin\src\feature;..\Marlin\src\feature\bedlevel;..\Marlin\src\feature\bedlevel\abl;..\Marlin\src\feature\bedlevel\mbl;..\Marlin\src\feature\bedlevel\ubl;..\Marlin\src\gcode;..\Marlin\src\HAL;..\Marlin\src\HAL\shared;..\Marlin\src\HAL\shared\backtrace;..\Marlin\src\HAL\HC32F46x;..\Marlin\src\HAL\HC32F46x\tft;..\Marlin\src\HAL\HC32F46x\inc;..\Marlin\src\inc;..\Marlin\src\lcd\language;..\Marlin\src\libs;..\Marlin\src\pins;..\Marlin\src\pins\hc32f46x;..\Marlin\src\lcd\extui;..\Marlin\src\lcd\extui\anycubic_kobra;..\Marlin\src\module;..\Marlin\src\module\stepper;..\Marlin\src\module\stepper\source;..\Marlin\src\module\thermistor;..\Marlin\src\sd;..\Marlin\lib\cores\arduino\avr;..\Marlin\lib\variants\generic_hc32f460;..\Marlin\lib\cores\ddl\cmsis;..\Marlin\lib\cores\arduino\series;..\Marlin\lib\cores\arduino\drivers;..\Marlin\lib\cores\arduino\drivers\adc;..\Marlin\lib\cores\arduino\drivers\gpio;..\Marlin\lib\cores\ddl\addon;..\Marlin\lib\cores\arduino\drivers\ots;..\Marlin\lib\cores\arduino\drivers\usart;..\Marlin\lib\cores\ddl\common;..\Marlin\lib\cores\ddl\startup;..\Marlin\lib\cores\arduino\main;..\Marlin\lib\cores\arduino\drivers\sysclock
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x78000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  link misc: --keep=*Handler
  group hdsc
    ../Marlin/lib/cores/ddl/startup/: startup_hc32f460.s
    ../Marlin/lib/cores/ddl/common/: system_hc32f460.c
    ../Marlin/lib/cores/arduino/drivers/gpio/: gpio.cpp
    ../Marlin/lib/cores/arduino/drivers/sysclock/: systick.cpp
    ../Marlin/lib/cores/arduino/drivers/adc/: adc.cpp
    ../Marlin/lib/cores/arduino/drivers/: board_sdio.cpp
    ../Marlin/lib/cores/arduino/main/: startup.cpp
  group hdsc_library
    ../Marlin/lib/cores/ddl/library/src/: hc32f460_adc.c hc32f460_aes.c hc32f460_can.c hc32f460_clk.c hc32f460_cmp.c hc32f460_crc.c hc32f460_dcu.c hc32f460_dmac.c hc32f460_efm.c hc32f460_emb.c hc32f460_event_port.c hc32f460_exint_nmi_swi.c hc32f460_gpio.c hc32f460_hash.c hc32f460_i2c.c hc32f460_i2s.c hc32f460_icg.c hc32f460_interrupts.c hc32f460_keyscan.c hc32f460_mpu.c hc32f460_ots.c hc32f460_pwc.c hc32f460_qspi.c hc32f460_rmu.c hc32f460_rtc.c hc32f460_sdioc.c hc32f460_spi.c hc32f460_sram.c hc32f460_swdt.c hc32f460_timer0.c hc32f460_timer4_cnt.c hc32f460_timer4_emb.c hc32f460_timer4_oco.c hc32f460_timer4_pwm.c hc32f460_timer4_sevt.c hc32f460_timer6.c hc32f460_timera.c hc32f460_trng.c hc32f460_usart.c hc32f460_wdt.c hc32f460_utility.c
  group cmsis
    ../Marlin/lib/cores/ddl/cmsis/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_cm4.h mpu_armv7.h cmsis_iccarm.h core_cm0.h core_cm0plus.h core_cm3.h core_cm7.h mpu_armv8.h tz_context.h
  group arduino
    ../Marlin/lib/cores/arduino/: HardwareSerial.cpp Print.cpp Stream.cpp WString.cpp Printable.h itoa.c WMath.cpp
    ../Marlin/lib/cores/arduino/main/: main.cpp
    ../Marlin/lib/cores/arduino/drivers/usart/: usart.h
  group board
    ../Marlin/lib/cores/arduino/main/: init.cpp
    ../Marlin/lib/cores/arduino/drivers/usart/: bsp_irq.cpp
    ../Marlin/lib/cores/arduino/drivers/adc/: bsp_adc.cpp
    ../Marlin/lib/cores/arduino/drivers/: bsp_pwm.cpp bsp_sdio.cpp bsp_timer.cpp bsp_wdt.cpp bsp_rmu.cpp
    ../Marlin/lib/cores/arduino/drivers/ots/: ots.cpp
  group SoftwareSerial
    ../Marlin/lib/libraries/SoftwareSerial/: SoftwareSerial.cpp
  group TMCStepper
    ../Marlin/lib/libraries/TMCStepper/source/: CHOPCONF.cpp COOLCONF.cpp DRV_CONF.cpp DRV_STATUS.cpp DRVCONF.cpp DRVCTRL.cpp DRVSTATUS.cpp ENCMODE.cpp GCONF.cpp IHOLD_IRUN.cpp PWMCONF.cpp RAMP_STAT.cpp SERIAL_SWITCH.cpp SERIAL_SWITCH.h SGCSCONF.cpp SHORT_CONF.cpp SMARTEN.cpp SW_MODE.cpp SW_SPI.h TMC_MACROS.h TMC_platforms.h TMC2208_bitfields.h TMC2208Stepper.cpp TMC2209_bitfields.h TMC2209Stepper.cpp TMCStepper.cpp
  group FatFs
    ../Marlin/lib/libraries/FatFs/: diskio.c ff.c ffconf.h ffsystem.c ffunicode.c
  group component
    ../Marlin/lib/middleware/sd_card/src/: sd_card.c sdmmc_cmd.c
    ../Marlin/lib/libraries/Utility/: rtdef.h
  group marlin
    ../Marlin/: Configuration.h Configuration_adv.h
    ../Marlin/src/inc/: Version.h
    ../Marlin/src/: MarlinCore.cpp
  group src_lcd
    ../Marlin/src/lcd/: marlinui.cpp lcdprint.cpp utf8.cpp
    ../Marlin/src/lcd/extui/: ui_api.cpp
    ../Marlin/src/lcd/extui/dgus_reloaded/: dgus_reloaded_extui.cpp DGUSScreenHandler.cpp DGUSSetupHandler.cpp DGUSDisplay.cpp DGUSRxHandler.cpp DGUSTxHandler.cpp
    ../Marlin/src/lcd/extui/dgus_reloaded/definition/: DGUS_ScreenAddrList.cpp DGUS_ScreenSetup.cpp DGUS_VPList.cpp DGUS_VP.h
    ../Marlin/src/lcd/extui/dgus_reloaded/config/: DGUS_Addr.h DGUS_Constants.h DGUS_Control.h DGUS_Data.h DGUS_Screen.h
  group src_cores
    ../Marlin/src/core/: utility.cpp serial.cpp serial.h language.h types.h boards.h multi_language.h debug_out.h drivers.h millis_t.h debug_section.h
    ../../../Kobra-updated/Marlin/src/core/: serial_hook.h serial_base.h
    ../Marlin/lib/cores/arduino/: wiring_digital.cpp flash.cpp iwdg.cpp Tone.cpp
  group src_feature
    ../Marlin/src/feature/bedlevel/: bedlevel.cpp
    ../Marlin/src/feature/: babystep.cpp controllerfan.cpp e_parser.cpp fwretract.cpp pause.cpp power_monitor.cpp repeat.cpp tmc_util.cpp z_stepper_align.cpp backlash.cpp host_actions.cpp
    ../Marlin/src/feature/bedlevel/abl/: bbl.cpp
  group src_gcode
    ../Marlin/src/gcode/bedlevel/abl/: G29.cpp M421.cpp
    ../Marlin/src/gcode/bedlevel/: G26.cpp G35.cpp G42.cpp M420.cpp
    ../Marlin/src/gcode/calibrate/: G28.cpp G33.cpp G34.cpp G34_M422.cpp G425.cpp M12.cpp M48.cpp M100.cpp M425.cpp M665.cpp M666.cpp M852.cpp G76_M871.cpp
    ../Marlin/src/gcode/config/: M43.cpp M92.cpp M200-M205.cpp M217.cpp M218.cpp M220.cpp M221.cpp M281.cpp M301.cpp M302.cpp M304.cpp M305.cpp M540.cpp M575.cpp M672.cpp M309.cpp
    ../Marlin/src/gcode/control/: M3-M5.cpp M7-M9.cpp M17_M18_M84.cpp M42.cpp M80_M81.cpp M85.cpp M108_M112_M410.cpp M111.cpp M120_M121.cpp M211.cpp M226.cpp M280.cpp M350_M351.cpp M380_M381.cpp M605.cpp M993_M994.cpp M997.cpp M999.cpp T.cpp M10-M11.cpp M282.cpp
    ../Marlin/src/gcode/eeprom/: M500-M504.cpp
    ../Marlin/src/gcode/feature/network/: M552-M554.cpp
    ../Marlin/src/gcode/feature/pause/: G27.cpp G60.cpp G61.cpp M125.cpp M600.cpp M603.cpp M701_M702.cpp
    ../Marlin/src/gcode/feature/power_monitor/: M430.cpp
    ../Marlin/src/gcode/feature/trinamic/: M122.cpp M569.cpp M906.cpp M911-M914.cpp M919.cpp
    ../Marlin/src/gcode/geometry/: G17-G19.cpp G53-G59.cpp G92.cpp M206_M428.cpp
    ../Marlin/src/gcode/host/: M16.cpp M110.cpp M113.cpp M114.cpp M115.cpp M118.cpp M119.cpp M360.cpp M876.cpp M154.cpp
    ../Marlin/src/gcode/lcd/: M0_M1.cpp M73.cpp M117.cpp M145.cpp M250.cpp M300.cpp M995.cpp M255.cpp M256.cpp M414.cpp
    ../Marlin/src/gcode/motion/: G0_G1.cpp G2_G3.cpp G4.cpp G5.cpp G6.cpp G80.cpp M290.cpp M400.cpp
    ../Marlin/src/gcode/probe/: G30.cpp G31_G32.cpp G38.cpp M401_M402.cpp M851.cpp M951.cpp M102.cpp M423.cpp
    ../Marlin/src/gcode/sd/: M20.cpp M21_M22.cpp M23.cpp M24_M25.cpp M26.cpp M27.cpp M28_M29.cpp M30.cpp M32.cpp M33.cpp M34.cpp M524.cpp M808.cpp M928.cpp M1001.cpp
    ../Marlin/src/gcode/stats/: M31.cpp M75-M78.cpp
    ../Marlin/src/gcode/temp/: M104_M109.cpp M105.cpp M106_M107.cpp M140_M190.cpp M141_M191.cpp M155.cpp M303.cpp M123.cpp M143_M193.cpp M192.cpp M306.cpp
    ../Marlin/src/gcode/units/: G20_G21.cpp M82_M83.cpp M149.cpp
    ../Marlin/src/gcode/: gcode.cpp gcode_d.cpp parser.cpp queue.cpp
    ../Marlin/src/gcode/feature/controllerfan/: M710.cpp
    ../Marlin/src/gcode/feature/advance/: M900.cpp
    ../Marlin/src/gcode/feature/fwretract/: G10_G11.cpp M207-M209.cpp
    ../Marlin/src/gcode/feature/input_shaping/: M593.cpp
    ../Marlin/src/gcode/scara/: M360-M364.cpp
    ../Marlin/src/gcode/feature/runout/: M412.cpp
    ../Marlin/src/gcode/feature/prusa_MMU2/: M403.cpp
    ../Marlin/src/gcode/feature/powerloss/: M413.cpp M1000.cpp
    ../Marlin/src/gcode/feature/password/: M510-M512.cpp
    ../Marlin/src/gcode/feature/mixing/: M163-M165.cpp M166.cpp
    ../Marlin/src/gcode/feature/macro/: M810-M819.cpp
    ../Marlin/src/gcode/feature/leds/: M150.cpp M7219.cpp
    ../Marlin/src/gcode/feature/i2c/: M260_M261.cpp
    ../Marlin/src/gcode/feature/filwidth/: M404-M407.cpp
    ../Marlin/src/gcode/feature/digipot/: M907-M910.cpp
    ../Marlin/src/gcode/feature/clean/: G12.cpp
    ../Marlin/src/gcode/feature/caselight/: M355.cpp
    ../Marlin/src/gcode/feature/cancel/: M486.cpp
    ../Marlin/src/gcode/feature/camera/: M240.cpp
    ../Marlin/src/gcode/feature/baricuda/: M126-M129.cpp
    ../Marlin/src/gcode/feature/adc/: M3426.cpp
    ../Marlin/src/gcode/feature/ft_motion/: M493.cpp
  group src_HAL
    ../Marlin/src/HAL/shared/: eeprom_api.cpp Marduino.h math_32bit.h Delay.cpp eeprom_if.h progmem.h MinSerial.cpp
    ../Marlin/src/HAL/HC32F46x/: eeprom_flash.cpp eeprom_sdcard.cpp endstop_interrupts.h HAL.cpp spi_pins.h timers.cpp sdio.cpp fastio.cpp HAL_SPI.cpp
    ../Marlin/src/HAL/HC32F46x/inc/: Conditionals_adv.h Conditionals_LCD.h Conditionals_post.h SanityCheck.h
    ../Marlin/src/HAL/: platforms.h
  group src_inc
    ../Marlin/src/inc/: Conditionals_adv.h Conditionals_LCD.h Conditionals_post.h MarlinConfig.h MarlinConfigPre.h SanityCheck.h Version.h
  group src_lib
    ../Marlin/src/libs/: bresenham.h buzzer.cpp circularqueue.h crc16.cpp duration_t.h hex_print.cpp nozzle.cpp numtostr.cpp private_spi.h softspi.h stopwatch.cpp vector_3.cpp
    ../Marlin/lib/cores/arduino/avr/: dtostrf.c pgmspace.h
  group src_module
    ../Marlin/src/module/stepper/: indirection.cpp trinamic.cpp speed_lookuptable.h
    ../Marlin/src/module/: endstops.cpp motion.cpp planner.cpp printcounter.cpp probe.cpp settings.cpp stepper.cpp temperature.cpp tool_change.cpp ft_motion.cpp ft_types.h
    ../Marlin/src/module/thermistor/: thermistors.h
  group src_pins
    ../Marlin/src/pins/: pins.h sensitive_pins.h pinsDebug.h pinsDebug_list.h pins_postprocess.h
    ../Marlin/src/pins/hc32f46x/: pins_AC_TRI_F1_V1.h
  group src_sd
    ../Marlin/src/sd/: cardreader.cpp SdBaseFile.cpp SdFatConfig.h SdFatStructs.h SdFatUtil.cpp SdFile.cpp SdInfo.h SdVolume.cpp
  group tests
    ../Marlin/src/tests/: marlin_tests.cpp
    ../Marlin/lib/app/: app_fatfs_test.cpp app_sserial_test.cpp
